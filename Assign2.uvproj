# Keil uVision project Assign2.uvproj, settings and files
target Project Folder (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: Assign2
  c flags: Optimize=8 SizeSpeed=1
  group Main Files
    ./: Assign2.c
